# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\BALANCE\CONTROL;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\BALANCE\CONTROL;..\BALANCE\DMP;..\BALANCE\filter;..\BALANCE\MPU6050;..\BALANCE\show;..\BALANCE\controls;..\HARDWARE\EXTI;..\HARDWARE\DataScope_DP;..\HARDWARE\CAN;..\HARDWARE\STMFLASH;..\HARDWARE\USARTX;..\USER;..\HARDWARE\PS2;..\HARDWARE\MY_USART;..\STM32F10x_FWLib\inc;..\MALLOC;..\JSON
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: Minibalance.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/USARTX/: usartx.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/MY_USART/: my_usart.c
  group BALANCE
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BALANCE/filter/: filter.c
    ../BALANCE/MPU6050/: MPU6050.c
    ../BALANCE/show/: show.c
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c
